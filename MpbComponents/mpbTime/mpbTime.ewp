# IAR project mpbTime.ewp, settings and files
configuration mpbtimeBaseCortexM0 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: Includes; \\srvdata01\commun\R&D Projects\Embedded Software Teams Management\Components\commun\V100
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nepTime.out
configuration mpbTimeBaseCortexM4 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  group Documents
    Documents/: Version.txt
  group Includes
    Includes/: mpbTimeBase.h
  group Sources
    Sources/: mpbTimeBase.c
